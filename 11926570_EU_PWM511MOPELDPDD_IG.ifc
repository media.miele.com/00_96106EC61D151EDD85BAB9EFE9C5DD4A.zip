Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-08-04T12:51:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 04 12:51:51 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\73f7099e-db9a-4115-acd4-ad45e5e99293\620b3010-a54a-4275-a312-011a6dd9ad52\ifc * Database version: 5507 * Database creation date: Thu Aug 04 12:51:50 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 04 12:51:51 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 04 12:51:51 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11926570_EU_PWM511MOPELDPDD_IG:51511034_EU_11926570_PWM511MOPELDPDD_IG, (2)
In: Default
Type - Material: z_Miele_Design_Stainless_Steel
Type - Pset_BuildingElementProxyCommon - Reference: 51511034_EU_11926570_PWM511MOPELDPDD_IG
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 51511034_EU_11926570_PWM511MOPELDPDD_IG
Material: z_Miele_Design_Stainless_Steel, z_Miele_Design_Glass, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Design_Iron_Grey, Default, z_Miele_Connection_Water_OUT, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Water_IN, z_Miele_Connection_Network, z_Miele_Connection_Electric, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - sets with these values: 2
